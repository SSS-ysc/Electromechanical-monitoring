# Keil uVision project STM32F429.uvprojx, settings and files
target YZU-15 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,__FPU_USED=1
  c include: ..\STM32\CMSIS\Device\ST\STM32F4xx\Include;..\STM32\CMSIS\Include;..\STM32\STM32F4xx_StdPeriph_Driver\inc;..\STM32\DSP\Include;..\STM32_DSP;..\UCOS;..\UCOS\BSP;..\UCOS\uC-CPU;..\UCOS\uC-CPU\ARM-Cortex-M4\RealView;..\UCOS\uC-LIB;..\UCOS\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOS\uCOS-III\Source;..\UCOS\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\emWin\Config;..\emWin\inc;..\emWin;..\emWin\font;..\MY;..\Drive\Include;..\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MY
    ../MY/: main.c stm32f4xx_it.c DSP.c MainTask.c Refresh.c bitmap.c yzubitmap.c
  group Drive
    ../UCOS/BSP/: bsp.c
    ../Drive/Source/: lcd_rgb.c lcd_pwm.c sdram.c touch_iic.c touch_070.c sdio_sd.c spi_flash.c delay.c rtc.c iwdg.c led&control.c key.c adc.c tim.c usart.c DHT11.c GPS.c 4G_linking.c 485.c WIFI.c
  group STM32
    ../STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ../STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../STM32/DSP/: arm_cortexM4lf_math.lib
    ../STM32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_crc.c stm32f4xx_dma2d.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c
  group emWin
    ../emWin/Config/: GUIConf.c emWin_Drive_ARGB.c
    ../emWin/OS/: GUI_X_OS.c
    ../emWin/: GUI_Touch.c
    ../emWin/Lib/: STemWin540_CM4_OS_Keil_ot_ARGB.lib
    ../emWin/font/: XBF_Font.c
  group UCOS
    ../UCOS/uC-CPU/: cpu_core.c
    ../UCOS/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCOS/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOS/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
    ../UCOS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../UCOS/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
    ../UCOS/: os_app_hooks.c
  group FatFs
    ../FatFs/: diskio.c ff.c ffunicode.c
  group DSP
    ../STM32_DSP/: cr4_fft_1024_stm32.s table_fft.h stm32_dsp.h
